# IAR project driverlib-cm4f.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM4F110B2QR TexasInstruments LM4F110B2QR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: driverlib-cm4f.srec
  ILINK.IlinkOutputFile: driverlib-cm4f.out
  group Source
    ./: adc.c can.c comp.c cpu.c eeprom.c epi.c ethernet.c fan.c flash.c fpu.c gpio.c hibernate.c i2c.c i2s.c interrupt.c lpc.c mpu.c peci.c pwm.c qei.c ssi.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
